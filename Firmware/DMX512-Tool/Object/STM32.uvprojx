# Keil uVision project STM32.uvprojx, settings and files
target DMX512_Tool (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CM3;..\Object;..\STM32F10x_FWLib\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\CODE\LED;..\CODE\SYS;..\CODE\USART;..\CODE\KEY;..\CODE\POWER;..\CODE\SPI;..\CODE\LCD;..\CODE\I2C;..\CODE\24CXX;..\CODE\GUI;..\CODE\RF;..\CODE\SI446X;..\CODE\MY9221;..\CODE\TM1829;..\CODE\ADC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_adc.c
  group CM3
    ../CM3/: startup_stm32f10x_md.s core_cm3.c
  group OBJ
    ./: main.c system_stm32f10x.c
  group CODE
    ../CODE/sys/: sys.c
    ../CODE/LED/: led.c
    ../CODE/POWER/: power.c
    ../CODE/KEY/: key.c
    ../CODE/LCD/: lcd.c
    ../CODE/SPI/: spi.c
    ../CODE/GUI/: gui.c
    ../CODE/24CXX/: 24cxx.c
    ../CODE/I2C/: i2c.c
    ../CODE/MY9221/: my9221.c
    ../CODE/RF/: rf.c
    ../CODE/SI446X/: si446x.c
    ../CODE/TM1829/: tm1829.c
    ../CODE/USART/: usart.c
    ../CODE/ADC/: adc.c
  group UCOSII
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c
    ../UCOSII/CORE/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
