# IAR project STM8S.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\STM8S_FWLib\inc; ..\CODE\SYS; ..\CODE\MCU; ..\CODE\UART; ..\CODE\DEBUG; ..\CODE\LED; ..\CODE\PWM; ..\CODE\I2C_DS; ..\CODE\DS3231; ..\CODE\I2C; ..\CODE\S4011; ..\CODE\POWER; ..\CODE\FLASH
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S.hex
  ILINK.IlinkOutputFile: STM8S.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group CODE
    ../CODE/DEBUG/: debug.c
    ../CODE/DS3231/: ds3231.c
    ../CODE/FLASH/: flash.c
    ../CODE/I2C/: i2c.c
    ../CODE/I2C_DS/: i2c_ds.c
    ../CODE/LED/: led.c
    ../CODE/MCU/: mcu.c
    ../CODE/POWER/: power.c
    ../CODE/S4011/: s4011.c
    ../CODE/SYS/: sys.c
    ../CODE/UART/: uart.c
  group FWLIB
    ../STM8S_FWLib/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_spi.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group OBJ
    ./: main.c
